<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvb-t/grc/input_dibit.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>dvbt_inner_coder</key>
<param><key>id</key><value>dvbt_inner_coder_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1000</value></param>
<param><key>constellation</key><value>qam16</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvb-t/grc/symbols_out_8.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1000</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvbt/grc/viterbi_out.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvbt/grc/tribit.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>dvbt_viterbi_decoder</key>
<param><key>id</key><value>dvbt_viterbi_decoder_0</value></param>
<param><key>type</key><value>b</value></param>
<param><key>fsm_args</key><value>1,3,[4,5,7]</value></param>
<param><key>block_size</key><value>34</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>final_state</key><value>-1</value></param>
</block>
<connection><source_block_id>gr_file_source_0_0</source_block_id><sink_block_id>dvbt_inner_coder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_inner_coder_0</source_block_id><sink_block_id>gr_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_viterbi_decoder_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>dvbt_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
