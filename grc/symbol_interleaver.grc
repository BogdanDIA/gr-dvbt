<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvbt/grc/deco_bi.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1512</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvbt-baruffa/test_si.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1512</value></param>
</block>
<block>
<key>dvbt_symbol_inner_interleaver</key>
<param><key>id</key><value>dvbt_symbol_inner_interleaver_0</value></param>
<param><key>transmission_mode</key><value>T2k</value></param>
<param><key>direction</key><value>Deinterleave</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>dvbt_symbol_inner_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_symbol_inner_interleaver_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
