<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvb-t/grc/captureBB.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvbt-baruffa/captureBB914.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>70</value></param>
<param><key>interp</key><value>64</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.00220971</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(2048)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>dvbt_ofdm_sym_acquisition</key>
<param><key>id</key><value>dvbt_ofdm_sym_acquisition_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_length</key><value>2048</value></param>
<param><key>occupied_tones</key><value>1705</value></param>
<param><key>cp_length</key><value>64</value></param>
<param><key>snr</key><value>50</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>2048</value></param>
</block>
<block>
<key>dvbt_demod_reference_signals</key>
<param><key>id</key><value>dvbt_demod_reference_signals_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>constellation</key><value>qam16</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>code_rate_hp</key><value>C1_2</value></param>
<param><key>code_rate_lp</key><value>C1_2</value></param>
<param><key>guard_interval</key><value>G1_32</value></param>
<param><key>transmission_mode</key><value>T2k</value></param>
<param><key>include_cell_id</key><value>cell_ide_no</value></param>
<param><key>cell_id</key><value>0</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_1_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1512</value></param>
</block>
<block>
<key>dvbt_dvbt_demap</key>
<param><key>id</key><value>dvbt_dvbt_demap_0</value></param>
<param><key>constellation</key><value>qam16</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>transmission_mode</key><value>T2k</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>dvbt_symbol_inner_interleaver</key>
<param><key>id</key><value>dvbt_symbol_inner_interleaver_0</value></param>
<param><key>transmission_mode</key><value>T2k</value></param>
<param><key>direction</key><value>Deinterleave</value></param>
</block>
<block>
<key>dvbt_bit_inner_deinterleaver</key>
<param><key>id</key><value>dvbt_bit_inner_deinterleaver_0</value></param>
<param><key>constellation</key><value>qam16</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>transmission_mode</key><value>T2k</value></param>
</block>
<block>
<key>dvbt_energy_descramble</key>
<param><key>id</key><value>dvbt_energy_descramble_0</value></param>
<param><key>nsize</key><value>8</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvb-t/grc/test_out.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>dvbt_reed_solomon_dec</key>
<param><key>id</key><value>dvbt_reed_solomon_dec_0</value></param>
<param><key>p</key><value>2</value></param>
<param><key>m</key><value>8</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>n</key><value>255</value></param>
<param><key>k</key><value>239</value></param>
<param><key>t</key><value>8</value></param>
<param><key>s</key><value>51</value></param>
<param><key>blocks</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>center_freq0</key><value>1280e6</value></param>
<param><key>gain0</key><value>19</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvb-t/gr-dvb-t/grc/captureBB.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>dvbt_viterbi_decoder</key>
<param><key>id</key><value>dvbt_viterbi_decoder_0</value></param>
<param><key>constellation</key><value>qam16</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>code_rate</key><value>C1_2</value></param>
<param><key>type</key><value>b</value></param>
<param><key>fsm_args</key><value>1,2,[0x79,0x5b]</value></param>
<param><key>block_size</key><value>1632</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>final_state</key><value>-1</value></param>
</block>
<block>
<key>dvbt_convolutional_deinterleaver</key>
<param><key>id</key><value>dvbt_convolutional_deinterleaver_0</value></param>
<param><key>blocks</key><value>136</value></param>
<param><key>I</key><value>12</value></param>
<param><key>M</key><value>17</value></param>
</block>
<connection><source_block_id>dvbt_demod_reference_signals_0</source_block_id><sink_block_id>dvbt_dvbt_demap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_dvbt_demap_0</source_block_id><sink_block_id>dvbt_symbol_inner_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_symbol_inner_interleaver_0</source_block_id><sink_block_id>dvbt_bit_inner_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>dvbt_demod_reference_signals_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_demod_reference_signals_0</source_block_id><sink_block_id>gr_null_sink_1_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_ofdm_sym_acquisition_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_ofdm_sym_acquisition_0</source_block_id><sink_block_id>dvbt_demod_reference_signals_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dvbt_reed_solomon_dec_0</source_block_id><sink_block_id>dvbt_energy_descramble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>dvbt_ofdm_sym_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_energy_descramble_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_convolutional_deinterleaver_0</source_block_id><sink_block_id>dvbt_reed_solomon_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0_0</source_block_id><sink_block_id>dvbt_ofdm_sym_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_bit_inner_deinterleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>dvbt_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_demod_reference_signals_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_ofdm_sym_acquisition_0</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_viterbi_decoder_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_viterbi_decoder_0</source_block_id><sink_block_id>dvbt_convolutional_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
