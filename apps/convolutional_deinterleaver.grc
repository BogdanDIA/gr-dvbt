<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>dvbt_convolutional_deinterleaver</key>
<param><key>id</key><value>dvbt_convolutional_deinterleaver_0</value></param>
<param><key>blocks</key><value>136</value></param>
<param><key>I</key><value>12</value></param>
<param><key>M</key><value>17</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/bogdan/ettus/dvbt-baruffa/test_ci.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>deco_rs.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1632</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>dvbt_convolutional_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_convolutional_deinterleaver_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
